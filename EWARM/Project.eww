<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F103C8T6_cubeIDE_ST7735_1.8_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
